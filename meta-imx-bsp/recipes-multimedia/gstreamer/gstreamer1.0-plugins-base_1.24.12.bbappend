GST_BASE_INC = ""
GST_BASE_INC:use-nxp-bsp = "gstreamer1.0-plugins-base.inc"
require ${GST_BASE_INC}
