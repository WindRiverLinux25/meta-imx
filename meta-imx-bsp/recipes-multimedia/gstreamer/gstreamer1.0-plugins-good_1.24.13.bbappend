GST_GOOD_INC = ""
GST_GOOD_INC:use-nxp-bsp = "gstreamer1.0-plugins-good.inc"
require ${GST_GOOD_INC}
