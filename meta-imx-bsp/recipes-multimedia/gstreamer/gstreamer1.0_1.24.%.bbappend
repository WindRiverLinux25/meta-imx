GST_INC = ""
GST_INC:use-nxp-bsp = "gstreamer1.0.inc"
require ${GST_INC}
