GST_BAD_INC = ""
GST_BAD_INC:use-nxp-bsp = "gstreamer1.0-plugins-bad.inc"
require ${GST_BAD_INC}
